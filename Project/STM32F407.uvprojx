# Keil uVision project STM32F407.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User;..\User\LED;..\User\TIM6;..\User\USART3;..\User\DWIN_LCD;..\User\CRC16;..\User\Encoder;..\User\FSMC;..\User\FPGA_Communication;..\User\DWIN_LCD_Communication
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f40_41xxx.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h stm32f4xx.h system_stm32f4xx.h system_stm32f4xx.c
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f4xx_crc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_dma2d.c
  group USER
    ../User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h includes.h
    ../User/LED/: LED.c
    ../User/TIM6/: TIME6.c
    ../User/DWIN_LCD/: DWIN_LCD.c
    ../User/CRC16/: CRC16.c
    ../User/Encoder/: TIME5_Encoder.c TIME3_Encoder.c
    ../User/FSMC/: FSMC.c
    ../User/FPGA_Communication/: FPGA_Communication.c
    ../User/DWIN_LCD_Communication/: DWIN_LCD_Communication.c
    ../User/USART3/: USART3.c
  group DOC
    ../Doc/: readme.txt
